# Keil uVision project STM32F103.uvprojx, settings and files
target GEC_F103 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c misc: --GNU
  c include: ..\..\CORE;..\..\FWLIB\inc;..\..\GEC_LIB;..\..\SYSTEM;..\src
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CORE
    ../../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../../FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../../SYSTEM/: uart.c ring_buffer.c fashion_star_uart_servo.c
  group GEC_LIB
    ../../GEC_LIB/: gec_gpio.c gec_init.c system_stm32f10x.c gec_int.c gec_time.c gec_uart.c gec_gpio.h gec_i2c.c gec_i2c.h gec_init.h gec_int.h gec_lib.h gec_time.h gec_uart.h stm32f10x.h stm32f10x_conf.h system_stm32f10x.h
  group USER
    ../src/: main.c key_and_led.c key_and_bee.c show_servo_contorl.c exit.c
